/* Скрипт линковки для второго этапа BIOS-загрузчика */

SECTIONS {
    . = 0x0600;
    .text : { *(.text*) }
    .data : { *(.data*) }
    .bss  : { *(.bss*) }
}
